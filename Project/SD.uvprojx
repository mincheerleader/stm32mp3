# Keil uVision project SD.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SD +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_CL
  c include: ..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\inc;..\Libraries\src;..\Startup;..\code;..\code\vs1053
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group LIB
    ../Libraries/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_exti.c
  group STAR
    ../Startup/: startup_stm32f10x_cl.s
  group code
    ../code/: main.c mmc_sd.c stm32f10x_it.c ini.c file.c bsp_usart2.c
    ../code/vs1053/: VS1053.c
software components: CMSIS:CORE 4.1.0
